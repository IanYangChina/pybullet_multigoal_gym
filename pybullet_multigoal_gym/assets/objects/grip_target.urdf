Commit message: hierarchical env

File: pybullet_multigoal_gym/assets/objects/grip_target.urdf (robot description, URDF)
Before this commit: robot block_target, 1 links, 0 joints
Links:
- removed link block_target
- added link grip_target, mass 0.0; visual sphere radius=0.01
