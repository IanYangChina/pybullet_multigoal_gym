Commit message: adjust workspace range & image-action mapping

File: pybullet_multigoal_gym/assets/objects/assembling_shape/workspace.urdf (robot description, URDF)
Before this commit: robot workspace, 2 links, 1 joints
Links:
- link range: geometry visual box size=0.35 0.35 0.001
